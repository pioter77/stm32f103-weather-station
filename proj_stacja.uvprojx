# Keil uVision project proj_stacja.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: proj_stacja
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: gp_drive.c gp_drive.h main.c sim800_drive.c sim800_drive.h str_lib.c str_lib.h systick_lib.c systick_lib.h uart_drive.c uart_drive.h adc_drive.c adc_drive.h main.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
